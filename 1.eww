<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\current_sensor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\voltage_regulator\voltage_regulator.ewp</path>
  </project>
  <batchBuild/>
</workspace>


